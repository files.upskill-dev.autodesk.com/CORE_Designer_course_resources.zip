28_Thicken_Freeform (Autodesk Fusion 360 design; units mm, degrees)
part number: 2026-07-16-15-20-06-071
form "Form1"