27_Bevel (Autodesk Fusion 360 design; units mm, degrees)
part number: 2026-07-16-15-14-50-052
form "Form1"